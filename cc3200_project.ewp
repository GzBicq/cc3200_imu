# IAR project cc3200_project.ewp, settings and files
configuration cc3200 (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; STM32F411xE; MPU9250; EMPL_TARGET_STM32F4; EMPL; USE_INV_LOG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\cc3200-sdk\inc; ..\cc3200-sdk\driverlib; ..\cc3200-sdk\example\common; $PROJ_DIR$; imu_drivert_core\core\driver\eMPL; imu_drivert_core\core\driver\include; imu_drivert_core\core\driver\stm32L; imu_drivert_core\core\eMPL-hal; imu_drivert_core\core\mllite; imu_drivert_core\core\mpl; imu_drivert_core\DeviceSupport\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cc3200_project.bin
  ILINK.IlinkOutputFile: cc3200_project.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ..\cc3200-sdk\driverlib\ewarm\Release\Exe\driverlib.a; imu_drivert_core\IAR\libmpllib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../cc3200-sdk/example/common/: gpio_if.c startup_ewarm.c
    ./: main.c pinmux.c
  group I2C
    ../cc3200-sdk/example/common/: i2c_if.c
    ./: i2c_module.c
  group imu_driver_core/core/driver/eMPL
    imu_drivert_core/core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group imu_driver_core/core/driver/stm32L
    imu_drivert_core/core/driver/stm32L/: log_stm32.c
  group imu_driver_core/core/eMPL-hal
    imu_drivert_core/core/eMPL-hal/: eMPL_outputs.c
  group imu_driver_core/core/mllite
    imu_drivert_core/core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group imu_driver_core/DevieSupport/src
    imu_drivert_core/DeviceSupport/src/: board-st_discovery.c
  group INT
    ./: gpio_int.c
  group TIM
    ./: dTim.c
    ../cc3200-sdk/example/common/: timer_if.c
  group UART
    ./: uart_module.c
